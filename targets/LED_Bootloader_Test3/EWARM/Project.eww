<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\LED_Bootloader_Test3.ewp</path>
  </project>
  <batchBuild />
</workspace>
